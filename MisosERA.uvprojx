# Keil uVision project MisosERA.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: APM32F407VG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MisosERA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x200000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c i2c.c main.h i2c.h QMA6100.c QMA6100.h i2c_accel.c i2c_accel.h DMA.c DMA.h
software components: CMSIS Driver:I2C:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:CAN 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EINT 1.0.1, Device:StdPeriph Drivers:FMC 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:I2C 1.0.1, Device:StdPeriph Drivers:RCM 1.0.1, Device:StdPeriph Drivers:USART 1.0.1
